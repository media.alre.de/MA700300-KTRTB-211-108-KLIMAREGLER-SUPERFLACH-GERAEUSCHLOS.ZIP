Properties of the parts of a building model (IFC2X3)

# File
Description: Raumtemperaturregler, Heizen/Kühlen, Aufputz superflach, 230 VAC, geräuschlos (Triac), ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MA700300, Raumtemperaturregler, Heizen/Kühlen, Aufputz superflach, 230 VAC, geräuschlos (Triac)
In: Raum
Description: Dieser Regler wurde speziell zur Heiz-/Kühlregelung in 2-Rohr-Leitungssystemen für Hotel, Wohn- und Geschäftsräume entwickelt und kann bis zu 5 Ventilstellantriebe (stromlos geschlossen) ansteuern. Der KTRTB erfasst mit einem internen Fühler die Raumtemperatur und aktiviert entsprechend der Abweichung zum eingestellten Sollwert die Heizung bzw. Kühlung. Durch die Verwendung eines Triacs als Schaltelement statt eines Relais/Bimetalls entstehen keine Schaltgeräusche im Betrieb. Mit einem internem Schalter kann der vorhanden Kontakteingang als ECO-Kontakt oder Standby-Kontakt konfiguriert werden. ECO-Funktion: Wird diese Funktion gewählt, wird im Heizbetrieb auf eine um 3 K geringere und im Kühlbetrieb auf eine um 3 K höhere Temperatur geregelt. Standby-Funktion: Wird diese Funktion gewählt, wird der Regler ausgeschaltet (Frostschutz weiterhin aktiv). Aufputz-/Wandmontage (4-Loch-Befestigung auf UP-Dose).; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MA700300; ModelLabel: KTRTB-211.108; GlobalTradeItemNumber: 4050528050236; ProductURL: https://alre.de/produkt_MA700300
Pset_Specification - NominalLength: 0.0785 m; NominalWidth: 0.078 m; NominalDepth: 0.0139 m; NetWeight: 0.052
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: weiß; Breite: 78; Höhe: 78.5; Tiefe: 13.9; RAL-Nummer: 9010; Anschluss: sonstige; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Öffner (NC); Messbereich: 5; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Schutzart (NEMA): sonstige; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Regelcharakteristik: sonstige; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 1; Temperatur ablesbar: no; Max. Kontaktbelastung: 0.065; Differenzwert: 0; Sensor extern: no; Thermische Rückkopplung: ohne; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MA700300.pdf
